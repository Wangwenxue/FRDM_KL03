# Keil uVision project I2C.uvprojx, settings and files
target KL02Z32-Flash (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x1FFFFE00,0x0800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: platinum_Flash
  AfterMake: fromelf --m32combined --output=outfile.s19  platinum_Flash.axf
  c flags: Optim=4
  c define: KEIL FREEDOM CMSIS
  c include: ..\..\..\src\projects\iic;..\..\..\src\common;..\..\..\src\cpu;..\..\..\src\cpu\headers;..\..\..\src\drivers\lptmr;..\..\..\src\drivers\mcg;..\..\..\src\drivers\pmc;..\..\..\src\drivers\rcm;..\..\..\src\drivers\smc;..\..\..\src\drivers\uart;..\..\..\src\drivers\iic;..\..\..\src\drivers\mma8451;..\..\..\src\drivers\cmp;..\..\..\src\platforms;..\..;..\startup_s
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffe00 size 0x200
  memory RVCT10: RAM 0x20000000 size 0x600
  group project
    ../startup_s/: startup_MKL03Z4.s
    ../../../src/projects/iic/: main.c
  group common
    ../../../src/common/: uif.c alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ../../../src/cpu/: nmi_isr_handler.c start.c sysinit.c arm_cm0.c
  group drivers
    ../../../src/drivers/uart/: uart.c Retarget.c Serial.c
    ../../../src/drivers/rcm/: rcm.c rcm.h
    ../../../src/drivers/mcg/: mcg_lite.c
    ../../../src/drivers/iic/: iic.c
    ../../../src/drivers/mma8451/: mma8451.c
  group platforms
    ../../../src/platforms/: freedom.h
